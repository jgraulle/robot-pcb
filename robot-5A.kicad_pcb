# Repository jgraulle/robot-pcb

File README.txt:

Generate file for jlcpcb production:
- Run DRC check
- Generating Gerbers
   - File -> Fabrication Outputs -> Gerbers (.gbr)
   - Select the folder "build"
   - Layer selection, List of layers that should be selected:
      - F.Cu
      - B.Cu
      - F.Paste
      - B.Paste
      - F.Silkscreen
      - B.Silkscreen
      - F.Mask
      - B.Mask
      - Edge.Cuts - (contain the board outline/cutouts.)
   - Jump to General Options and check these:
      - Select Plot reference designators, otherwise designators will not appear on silkscreen layers
      - Select Plot footprint text
      - Select Check zone fills before plotting
      - Select Tent vias
      - Select Use Protel filename extensions, this is recommended as JLCPCB prefers Protel filename extensions
      - Select Subtract soldermask from silkscreen, this ensures no silkscreen on pads
   - Click the Plot button at the bottom of the window
- Generate Drill files
   - From previous window press the "Generate Drill files..." button
   - Check Use alternate drill mode for "Oval Holes Drill Mode"
   - Check Absolute for "Drill Origin"
   - Check Millimeters for "Drill Units"
   - Check Decimal format for "Zeros Format"
   - Click the Generate Drill File button, the drill files will be generated and stored in the output folder
- Generate Drill Map file
   - From previous window press the "Generate Map File" button and everything is going to be done automatically.
- Generate Bill of Materials
   - From Schematic Layout Editor. From the menu bar, click Tool -> Generate Bill of Materials
   - In edit tab, Only check in this order:
      - "Value" with label "Comment"
      - "Reference" with label "Designator"
      - "Package" with label "Footprint"
      - "LCSC" with label "LCSC part number"
   - In export tab:
       Set output file "build/robot-5A-bom.csv"
      - Clic on export
- Generate Pick and Place files
   - From the PCB editor, click on File -> Fabrication output -> Footprint position (.pos) file and export the file with the following settings:
      - CSV
      - mm
      - One file per side
      - Use drilling/placement origin
   - Run the scrip "jlcGenerate.sh"

## KiCad design robot-5A.kicad_pcb

Parts:
BZ1: Buzzer; MagneticBuzzer_PUI_AT-0927-TT-6-R; MPN QMB-09B-03; LCSC C96256
C101, C102, C103: 100n; C_0805_2012Metric; Tolerance <=10%; LCSC C28233
D101, D102: PMEG1020EH; D_SOD-123F; MPN PMEG1020EH; LCSC C552798
J101, J102: Conn_01x02; JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical; MPN XH 2.54; LCSC C158012
J103: Conn_01x03; JST_XH_B3B-XH-AM_1x03_P2.50mm_Vertical; MPN XH 2.54; LCSC C144394
J105: USB_C_Receptacle_PowerOnly_6P; USB_C_Receptacle_SHOU-HAN_TYPE-C-6P-LT-10.5; MPN TYPE-C 6P LT-10.5; LCSC C2681551
Q101: N-MOSFET; SOT-23; MPN AO3414; LCSC C48850
R101, R105, R109: 10k; R_0805_2012Metric; Tolerance <=1%; LCSC C17414
R102, R104: 1k; R_0805_2012Metric; Tolerance <=1%; LCSC C17513
R103: 0R; R_0805_2012Metric; LCSC C844192
R106, R107: 5.1k 1%; R_0805_2012Metric; Tolerance <=1%; LCSC C27834
R108: 22k; R_0805_2012Metric; Tolerance <=1%; LCSC C17560
SW101: SW_DIP_x01; SW_DIP_SPSTx01_Slide_9.78x4.72mm_W7.62mm_P2.54mm; LCSC C126888
SW102: SW_SPDT; SW_Slide_1P2T_SS-12F45; MPN SS-12F45-G040; LCSC C2876011
U101: MCP6001T-I/OT; SOT-23-5; LCSC C116490
U102, U103: ESP32-DEVKITC; MODULE_ESP32-DEVKITC; PARTREV N/A; LCSC C2932678

Connections:
+3.3V: C101.2, C102.2, R103.2, SW101.1, U101.5 (V+); also elsewhere on the board
+5V: D101.2 (A), SW102.2 (B); also elsewhere on the board
+BATT: R108.1; also elsewhere on the board
/Interface Pont H - Moteurs/mot1.out1: J101.1; also elsewhere on the board
/Interface Pont H - Moteurs/mot1.out2: J101.2; also elsewhere on the board
/Interface Pont H - Moteurs/mot2.out1: J102.1; also elsewhere on the board
/Interface Pont H - Moteurs/mot2.out2: J102.2; also elsewhere on the board
/Interface Pont H - Moteurs/~sleep: SW101.2; also elsewhere on the board
/Power Supply/5V_out: SW102.1 (A); also elsewhere on the board
/Power Supply/batt.in+: J103.1; also elsewhere on the board
/batt.sense.protect: R102.2, U102.3 (SENSOR_VP)
/buzzer: R104.1, R105.1, U103.27 (IO16)
/lcd.i2c.scl: U102.11 (IO27); also elsewhere on the board
/lcd.i2c.sda: U102.12 (IO14); also elsewhere on the board
/mot1.ctrl1: U102.13 (IO12); also elsewhere on the board
/mot1.ctrl2: U102.15 (IO13); also elsewhere on the board
/mot2.ctrl1: U103.24 (IO2); also elsewhere on the board
/mot2.ctrl2: U103.26 (IO4); also elsewhere on the board
/sd.spi.clk: U103.29 (IO5); also elsewhere on the board
/sd.spi.cs: U103.23 (IO15); also elsewhere on the board
/sd.spi.miso: U103.25 (IO0); also elsewhere on the board
/sd.spi.mosi: U103.28 (IO17); also elsewhere on the board
/sensor.1.adcIn: U102.4 (SENSOR_VN); also elsewhere on the board
/sensor.1.din: U102.5 (IO34); also elsewhere on the board
/sensor.2.adcIn: U102.6 (IO35); also elsewhere on the board
/sensor.2.din: U102.7 (IO32); also elsewhere on the board
/sensor.3.adcIn: U102.8 (IO33); also elsewhere on the board
/sensor.3.din: U102.10 (IO26); also elsewhere on the board
/sensor.4.din: U103.30 (IO18); also elsewhere on the board
/sensor.5.din: U103.33 (IO21); also elsewhere on the board
/sensor.5.dout: U103.31 (IO19); also elsewhere on the board
/sensor.6.din: U103.37 (IO23); also elsewhere on the board
/sensor.6.dout: U103.36 (IO22); also elsewhere on the board
/~fault: U102.9 (IO25); also elsewhere on the board
GND: C101.1, C102.1, C103.2, J103.3, J105.A12 (GND), J105.B12 (GND), J105.S1 (SHIELD), Q101.2 (S), R105.2, R106.1, R107.1, R109.2, U101.2 (V-), U102.14 (GND1), U103.32 (GND2), U103.38 (GND3); also elsewhere on the board
unnamed 48: D102.2 (A), Q101.3 (D); also elsewhere on the board
unnamed 49: D102.1 (K), R103.1; also elsewhere on the board
unnamed: D101.1 (K), U102.19 (EXT_5V)
unnamed: J105.A5 (CC1), R106.2
unnamed: J105.B5 (CC2), R107.2
unnamed: Q101.1 (G), R104.2
unnamed: R101.2, R102.1, U101.1
unnamed: J105.A9 (VBUS), J105.B9 (VBUS), SW102.3 (C)
unnamed: C103.1, R108.2, R109.1, U101.3 (+)
unnamed: R101.1, U101.4 (-)

Parts of its further copies:
BZ101: Buzzer; MagneticBuzzer_PUI_AT-0927-TT-6-R; MPN QMB-09B-03; LCSC C96256

Connections of its further copies:
unnamed 48: BZ101.2 (+); also elsewhere on the board
unnamed 49: BZ101.1 (-); also elsewhere on the board

Notes on the sheet:
Vers enroulement moteur 1
R1=10kΩ R2=22kΩ Alpha = 3.125000e-01 V/V Fullscale = 10.560 V ADC_gain = 2.578125e-03 V/LSB
X : Pins non utilisées - Réservées Flash interne Maximum drive strength by default 20mA => output protection = 200R
Vers enroulement moteur 2
Buzzer - Pour les alarmes Signalisation sonore.

Parts:
C201, C202, C203: 100n; C_0805_2012Metric; Tolerance <=10%; LCSC C28233
D6, D7, D8: LED Jaune; LED_0805_2012Metric; MPN KP-2012SYCK; LCSC C2296
D9: LED Rouge; LED_0805_2012Metric; MPN KP-2012SURCK; LCSC C84256
R201, R202, R203, R205, R208, R210, R213: 1k; R_0805_2012Metric; Tolerance <=1%; LCSC C17513
R204, R206, R207, R209, R211, R212: 10k; R_0805_2012Metric; Tolerance <=1%; LCSC C17414
U201, U202, U203: 74LVC2G17; SOT-23-6; MPN SN74LVC2G17DBVR; LCSC C10429
U204, U205: DRV8833; DVR8833_EVM; LCSC C40877

Connections:
+3.3V: C201.1, C202.1, C203.1, R212.1, U201.5 (VCC), U202.5 (VCC), U203.5 (VCC); also elsewhere on the board
+BATT: U204.9 (VCC); also elsewhere on the board
/Interface Pont H - Moteurs/mot1.ctrl2.trig: R202.1, U201.4, U204.8 (IN2)
/Interface Pont H - Moteurs/mot1.ctrl.trig: R201.1, U201.6, U204.7 (IN1)
/Interface Pont H - Moteurs/mot1.out1: U205.2 (OUT1); also elsewhere on the board
/Interface Pont H - Moteurs/mot1.out2: U205.3 (OUT2); also elsewhere on the board
/Interface Pont H - Moteurs/mot2.ctrl1.trig: R203.1, U202.6, U204.11 (IN3)
/Interface Pont H - Moteurs/mot2.ctrl2.trig: R205.1, U202.4, U204.12 (IN4)
/Interface Pont H - Moteurs/mot2.out1: U205.4 (OUT3); also elsewhere on the board
/Interface Pont H - Moteurs/mot2.out2: U205.5 (OUT4); also elsewhere on the board
/Interface Pont H - Moteurs/~fault.trig: R210.1, R213.2, U203.6
/Interface Pont H - Moteurs/~sleep.trig: R208.1, U203.4, U205.1 (EEP)
/Interface Pont H - Moteurs/~sleep: R211.1, U203.3; also elsewhere on the board
/mot1.ctrl1: R204.1, U201.1; also elsewhere on the board
/mot1.ctrl2: R206.1, U201.3; also elsewhere on the board
/mot2.ctrl1: R207.1, U202.1; also elsewhere on the board
/mot2.ctrl2: R209.1, U202.3; also elsewhere on the board
/~fault: R213.1; also elsewhere on the board
GND: C201.2, C202.2, C203.2, R204.2, R206.2, R207.2, R209.2, R211.2, U201.2 (GND), U202.2 (GND), U203.2 (GND), U204.10 (GND); also elsewhere on the board
unnamed 53: R201.2; also elsewhere on the board
unnamed 54: R202.2; also elsewhere on the board
unnamed 55: R203.2; also elsewhere on the board
unnamed 56: R205.2; also elsewhere on the board
unnamed 57: R208.2; also elsewhere on the board
unnamed 58: R210.2; also elsewhere on the board
unnamed: R212.2, U203.1, U205.6 (ULT)

Parts of its further copies:
D201, D202, D203: LED Jaune; LED_0805_2012Metric; MPN KP-2012SYCK; LCSC C2296
D206: LED Rouge; LED_0805_2012Metric; MPN KP-2012SURCK; LCSC C84256

Connections of its further copies:
+3.3V: D206.2 (A); also elsewhere on the board
GND: D201.1 (K), D202.1 (K), D203.1 (K); also elsewhere on the board
unnamed 53: D201.2 (A); also elsewhere on the board
unnamed 54: D202.2 (A); also elsewhere on the board
unnamed 55: D203.2 (A); also elsewhere on the board
unnamed 58: D206.1 (K); also elsewhere on the board

Notes on the sheet:
Moteur ContrC4le Table logique Motx_Ctrl1 et Motx_Ctrl2 Motx_Ctrl1 Motx_Ctrl2 Action 0 0 Freinage Rapide 0 1 Sens rotation Reverse 1 0 Sens rotation Forward 1 1 Freinage Lent
Switch : Quand ON, mode Sleep (GND)
Interface Pont en H Pilotage des Moteurs Liens avec les deux Moteurs:

Parts:
C521, C522, C523: 100n; C_0805_2012Metric; Tolerance <=10%; LCSC C28233
C524, C525: 1u; C_0805_2012Metric; Tolerance <=10%; LCSC C28323
D521: PMEG1020EH; D_SOD-123F; MPN PMEG1020EH; LCSC C552798; not fitted
J521: Conn_01x06; JST_XH_B6B-XH-AM_1x06_P2.50mm_Vertical; MPN XH 2.54; LCSC C144397
R521, R522, R523, R525, R526, R528: 1k; R_0805_2012Metric; Tolerance <=1%; LCSC C17513
R524, R527, R529: 10k; R_0805_2012Metric; Tolerance <=1%; LCSC C17414
U521: MCP6001T-I/OT; SOT-23-5; LCSC C116490
U522: 74LVC2G17; SOT-23-6; MPN SN74LVC2G17DBVR; LCSC C10429

Connections:
+3.3V: C522.2, C523.1, C525.1, D521.1 (K), J521.1, U521.5 (V+), U522.5 (VCC); also elsewhere on the board
+5V: C524.1, J521.3; also elsewhere on the board
/Sensors2/sensor.dout: R529.1, U522.3
/sensor.2.adcIn: C521.2, R522.1; also elsewhere on the board
/sensor.2.din: R525.1; also elsewhere on the board
GND: C521.1, C522.1, C523.2, C524.2, C525.2, J521.2, R524.2, R527.2, R529.2, U521.2 (V-), U522.2 (GND); also elsewhere on the board
unnamed: D521.2 (A), R521.1, U521.3 (+)
unnamed: J521.4, R521.2, R524.1
unnamed: J521.5, R526.2, R527.1
unnamed: J521.6, R528.2
unnamed: R522.2, R523.2, U521.1
unnamed: R525.2, U522.6
unnamed: R526.1, U522.1
unnamed: R528.1, U522.4
unnamed: R523.1, U521.4 (-)

Parts of its further copies:
C511, C512, C513, C531, C532, C533, C541, C542, C543, C551, C552, C553, C561, C562, C563: 100n; C_0805_2012Metric; Tolerance <=10%; LCSC C28233
C514, C515, C534, C535, C544, C545, C554, C555, C564, C565: 1u; C_0805_2012Metric; Tolerance <=10%; LCSC C28323
D511, D531, D541, D551, D561: PMEG1020EH; D_SOD-123F; MPN PMEG1020EH; LCSC C552798; not fitted
J511, J531, J541, J551, J561: Conn_01x06; JST_XH_B6B-XH-AM_1x06_P2.50mm_Vertical; MPN XH 2.54; LCSC C144397
R511, R512, R513, R515, R516, R518, R531, R532, R533, R535, R536, R538, R541, R542, R543, R545, R546, R548, R551, R552, R553, R555, R556, R558, R561, R562, R563, R565, R566, R568: 1k; R_0805_2012Metric; Tolerance <=1%; LCSC C17513
R514, R517, R519, R534, R537, R539, R544, R547, R549, R554, R557, R559, R564, R567, R569: 10k; R_0805_2012Metric; Tolerance <=1%; LCSC C17414
U511, U531, U541, U551, U561: MCP6001T-I/OT; SOT-23-5; LCSC C116490
U512, U532, U542, U552, U562: 74LVC2G17; SOT-23-6; MPN SN74LVC2G17DBVR; LCSC C10429

Connections of its further copies:
+3.3V: C512.2, C513.1, C515.1, C532.2, C533.1, C535.1, C542.2, C543.1, C545.1, C552.2, C553.1, C555.1, C562.2, C563.1, C565.1, D511.1 (K), D531.1 (K), D541.1 (K), D551.1 (K), D561.1 (K), J511.1, J531.1, J541.1, J551.1, J561.1, U511.5 (V+), U512.5 (VCC), U531.5 (V+), U532.5 (VCC), U541.5 (V+), U542.5 (VCC), U551.5 (V+), U552.5 (VCC), U561.5 (V+), U562.5 (VCC); also elsewhere on the board
+5V: C514.1, C534.1, C544.1, C554.1, C564.1, J511.3, J531.3, J541.3, J551.3, J561.3; also elsewhere on the board
/Sensors1/sensor.dout: R519.1, U512.3
/Sensors3/sensor.dout: R539.1, U532.3
/Sensors4/sensor.adcIn: C541.2, R542.1
/Sensors4/sensor.dout: R549.1, U542.3
/Sensors5/sensor.adcIn: C551.2, R552.1
/Sensors6/sensor.adcIn: C561.2, R562.1
/sensor.1.adcIn: C511.2, R512.1; also elsewhere on the board
/sensor.1.din: R515.1; also elsewhere on the board
/sensor.3.adcIn: C531.2, R532.1; also elsewhere on the board
/sensor.3.din: R535.1; also elsewhere on the board
/sensor.4.din: R545.1; also elsewhere on the board
/sensor.5.din: R555.1; also elsewhere on the board
/sensor.5.dout: R559.1, U552.3; also elsewhere on the board
/sensor.6.din: R565.1; also elsewhere on the board
/sensor.6.dout: R569.1, U562.3; also elsewhere on the board
GND: C511.1, C512.1, C513.2, C514.2, C515.2, C531.1, C532.1, C533.2, C534.2, C535.2, C541.1, C542.1, C543.2, C544.2, C545.2, C551.1, C552.1, C553.2, C554.2, C555.2, C561.1, C562.1, C563.2, C564.2, C565.2, J511.2, J531.2, J541.2, J551.2, J561.2, R514.2, R517.2, R519.2, R534.2, R537.2, R539.2, R544.2, R547.2, R549.2, R554.2, R557.2, R559.2, R564.2, R567.2, R569.2, U511.2 (V-), U512.2 (GND), U531.2 (V-), U532.2 (GND), U541.2 (V-), U542.2 (GND), U551.2 (V-), U552.2 (GND), U561.2 (V-), U562.2 (GND); also elsewhere on the board
unnamed: D511.2 (A), R511.1, U511.3 (+)
unnamed: D531.2 (A), R531.1, U531.3 (+)
unnamed: D541.2 (A), R541.1, U541.3 (+)
unnamed: D551.2 (A), R551.1, U551.3 (+)
unnamed: D561.2 (A), R561.1, U561.3 (+)
unnamed: J511.4, R511.2, R514.1
unnamed: J511.5, R516.2, R517.1
unnamed: J511.6, R518.2
unnamed: J531.4, R531.2, R534.1
unnamed: J531.5, R536.2, R537.1
unnamed: J531.6, R538.2
unnamed: J541.4, R541.2, R544.1
unnamed: J541.5, R546.2, R547.1
unnamed: J541.6, R548.2
unnamed: J551.4, R551.2, R554.1
unnamed: J551.5, R556.2, R557.1
unnamed: J551.6, R558.2
unnamed: J561.4, R561.2, R564.1
unnamed: J561.5, R566.2, R567.1
unnamed: J561.6, R568.2
unnamed: R512.2, R513.2, U511.1
unnamed: R515.2, U512.6
unnamed: R516.1, U512.1
unnamed: R518.1, U512.4
unnamed: R532.2, R533.2, U531.1
unnamed: R535.2, U532.6
unnamed: R536.1, U532.1
unnamed: R538.1, U532.4
unnamed: R542.2, R543.2, U541.1
unnamed: R545.2, U542.6
unnamed: R546.1, U542.1
unnamed: R548.1, U542.4
unnamed: R552.2, R553.2, U551.1
unnamed: R555.2, U552.6
unnamed: R556.1, U552.1
unnamed: R558.1, U552.4
unnamed: R562.2, R563.2, U561.1
unnamed: R565.2, U562.6
unnamed: R566.1, U562.1
unnamed: R568.1, U562.4
unnamed: R513.1, U511.4 (-)
unnamed: R533.1, U531.4 (-)
unnamed: R543.1, U541.4 (-)
unnamed: R553.1, U551.4 (-)
unnamed: R563.1, U561.4 (-)

Notes on the sheet:
Filtre RC passe-bas 1k + 100n: Fréquence de coupure -3 dB => 1,5915 kHz
Partie Capteurs: Capteur de position Capteur de contact

Parts:
C411, C412, C415, C416, C421, C422, C425, C426: 10u; C_1210_3225Metric; Tolerance <=10%; LCSC C39232
C413, C423: 1u; C_0805_2012Metric; Tolerance <=10%; LCSC C28323
C414, C424: 100n; C_0805_2012Metric; Tolerance <=10%; LCSC C28233
F1: Fuse; Fuse_1206_3216Metric; LCSC C182310
L411: 22µH; L_KOHERelec_MDA-7050; LCSC C2847545
L412: 15µH; L_KOHERelec_MDA-7050; LCSC C2847544
R411: 52.3k; R_0805_2012Metric; Tolerance <=1%; LCSC C2078257
R412, R422: 10k; R_0805_2012Metric; Tolerance <=1%; LCSC C17414
R413, R423: 0R; R_0805_2012Metric; LCSC C844192
R421: 31.6k; R_0805_2012Metric; Tolerance <=1%; LCSC C170879
U401, U402: MCP16311MNY; TDFN-8-1EP_3x2mm_P0.5mm_EP1.60x1.50mm; MPN MCP16311T-E/MNY; LCSC C510882

Connections:
+3.3V: R423.2; also elsewhere on the board
+5V: C421.2, C422.2, U402.3 (EN), U402.4 (Vin); also elsewhere on the board
+BATT: C411.2, C412.2, U401.3 (EN), U401.4 (Vin); also elsewhere on the board
/Power Supply/5V_out: R413.2; also elsewhere on the board
GND: C411.1, C412.1, C413.2, C415.1, C416.1, C421.1, C422.1, C423.2, C425.1, C426.1, R412.2, R422.2, U401.5 (PGND), U401.8 (AGND), U401.9 (PAD), U402.5 (PGND), U402.8 (AGND), U402.9 (PAD); also elsewhere on the board
unnamed: C415.2, C416.2, L411.2, R411.1, R413.1
unnamed: C425.2, C426.2, L412.2, R421.1, R423.1
unnamed: C414.1, U401.7 (BOOST)
unnamed: C414.2, L411.1, U401.6 (SW)
unnamed: C413.1, U401.2 (Vcc)
unnamed: R411.2, R412.1, U401.1 (Vfb)
unnamed: C424.1, U402.7 (BOOST)
unnamed: C424.2, L412.1, U402.6 (SW)
unnamed: C423.1, U402.2 (Vcc)
unnamed: R421.2, R422.1, U402.1 (Vfb)

Parts of its further copies:
F401: Fuse; Fuse_1206_3216Metric; LCSC C182310

Connections of its further copies:
+BATT: F401.2; also elsewhere on the board
/Power Supply/batt.in+: F401.1; also elsewhere on the board

Notes on the sheet:
Bloc Batteries: Deux batteries LiIon en série. Possible mise en parallèle de deux blocs série. Tension nominale par batonnet: 3,6 C 3,7Vdc Tension Nominale par bloc: 7,2 C 7,4Vdc - max 8,4V (4,2V/batonnet) - min 6,4V (3,2V/batonnet)
Rtop = Rbot x (Vout/Vfb - 1) = 10k x (3.3 / 0.8 - 1) = 31.25k => 31.6k Vout = (Rtop/Rbot+1) x Vfb = (31.6k/10k+1) x 0.8 = 3.328V
Vout: 3.3V Iout: 0.8A Efficiency: 87% Ldcr = 0.1Ohm Jonction = 211°C/W D = Vout / Vin Vin: 6V => D = 3.3/6 = 0.55 Vin: 8.4V=> D = 3.3/8.4 = 0.39 ton = D * Fs Vin: 6V => ton = 0.55 x 1/500kMhz = 1.1us Vin: 8.4V => ton = 0.39 x 1/500kMhz = 0.78us DeltaIl = (Vin - Vout) / L x ton Vin: 6V => DeltaIl = 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
Vout: 5V Iout: 0.8A Ldcr = 0.1Ohm Jonction = 211°C/W D = Vout / Vin Vin: 6V => D = 5/6 = 0.83 Vin: 8.4V=> D = 5/8.4 = 0.60 ton = D * Fs Vin: 6V => ton = 0.83 x 1/500kMhz = 1.66us Vin: 8.4V => ton = 0.60 x 1/500kMhz = 1.2us DeltaIl = (Vin - Vout) / L x ton Vin: 6V => DeltaIl = (6-5)V / 22uH x 1.66us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
Rtop = Rbot x (Vout/Vfb - 1) = 10k x (5 / 0.8 - 1) = 52.5k => 52.3k Vout = (Rtop/Rbot+1) x Vfb = (52.3k/10k+1) x 0.8 = 4.984V
