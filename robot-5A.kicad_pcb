# Repository jgraulle/robot-pcb (continued)

## KiCad design robot-5A.kicad_pcb (continued)

Parts:
C301, C302: 100n; C_0805_2012Metric; Tolerance <=10%; LCSC C28233
J10: Conn_01x06; PinSocket_1x06_P2.54mm_Vertical; LCSC C40877
J302: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical; LCSC C6332197
R301, R302, R303, R304, R305, R306: 200R; R_0805_2012Metric; Tolerance <=1%; LCSC C17540

Connections:
+3.3V: C301.1; also elsewhere on the board
+5V: C302.1, J302.2; also elsewhere on the board
/lcd.i2c.scl: R306.2; also elsewhere on the board
/lcd.i2c.sda: R305.1; also elsewhere on the board
/sd.spi.clk: R303.1; also elsewhere on the board
/sd.spi.cs: R301.1; also elsewhere on the board
/sd.spi.miso: R304.1; also elsewhere on the board
/sd.spi.mosi: R302.1; also elsewhere on the board
GND: C301.2, C302.2, J302.1; also elsewhere on the board
unnamed 67: R301.2; also elsewhere on the board
unnamed 68: R302.2; also elsewhere on the board
unnamed 69: R303.2; also elsewhere on the board
unnamed 70: R304.2; also elsewhere on the board
unnamed: J302.3, R305.2
unnamed: J302.4, R306.1

Parts of its further copies:
J301: Conn_01x06; PinSocket_1x06_P2.54mm_Vertical; LCSC C40877

Connections of its further copies:
+3.3V: J301.1; also elsewhere on the board
GND: J301.6; also elsewhere on the board
unnamed 67: J301.2; also elsewhere on the board
unnamed 68: J301.3; also elsewhere on the board
unnamed 69: J301.4; also elsewhere on the board
unnamed 70: J301.5; also elsewhere on the board

Notes on the sheet:
Ecran LCD : Interface (2 Lignes X 16 Colonnes Utilisation Interface I2C 1: Gnd 2: 5Vdc 3: SDA 4: SCL
Carte Micro SD : Module Référence (MircoSD Card Module) 1: 3,3Vdc 2: CS 3: MOSI 4: CLK 5: MISO 6: Gnd

Board: 2 copper layers, 100.0 x 100.0 mm, 193 parts (3 on the bottom side), 135 nets.

Other parts of the board:
D204: LED Jaune; LED_0805_2012Metric
D205: LED Verte; LED_0805_2012Metric

Their connections:
GND: D204.1 (K), D205.1 (K); also elsewhere on the board
unnamed 56: D204.2 (A); also elsewhere on the board
unnamed 57: D205.2 (A); also elsewhere on the board

## Commit log

2023-10-07 Initial commit, ongoing schematic design
2023-10-08 Make some improvement on shcema mainly on sensor page
2023-10-11 Fix all ECR warning and error and remove duplicated sensors schema
2023-10-12 PCB routing with ECR check
2023-10-12 Add gpio num for DRV8833, buzzer and BattSense
2023-10-12 Add gpio num for sensor, LCD and SD (change card size to 100x100mm)
2023-10-12 Fix from Guillaume remarks:
    - 200R => 1k For din/dout/adc
    - add capa for buzzer
    - add aop diode protection
    - fix RC sensor adc filter
2023-10-13 Replace LT8610 by MCP16311 to decrease price (schema only)
2023-10-14 Replace LT8610 by MCP16311 to decrease price (pcb)
    Schema fix fault LED from H-brige
2023-10-15 Remove convert 3.3V choice from 5V or bat and fix from 5V only Remove 3.3V from Esp32 pin header
2023-10-16 Add lcsc part number (and change some footprint)
2023-10-16 Replace 1x02 pin header by DIP switch to enable H-bridge
2023-10-17 Update TODO when remove 1x02 pin header by DIP switch
2023-10-17 Improve space between composant and track
2023-10-17 Update LCSC part number with basic version if exist to decrease price
2023-10-17 Uniform BOM column and add red dot on all >2 pad components
2023-10-17 Fix LED fault orientation
2023-10-17 Add USB C connector and switch to select 5V from USB-C or 5V DC/DC out
2023-10-17 Add M3 Monting hole
2023-10-17 Update PCB
2023-10-17 Add script to generate BOM and pos in JLCPCB format
2023-10-17 Fix some component name
2023-10-17 Some design review remarks added
2023-10-17 Add pin header female for ESP32, DRV8833 and SD card
2023-10-17 taken into account power supply remarks
2023-10-17 taken into account sensors remarks
2023-10-17 taken into account USB-C remark
2023-10-17 taken into account bat sense remark
2023-10-17 taken into account power switch remark
2023-10-18 Split DVR8833_EVM into IN and OUT to be able to have a pin header for each
2023-10-18 Split ESP32-DevKicC into Left and Right to be able to have a pin header for each
2023-10-18 Do not include JST XH in BOM and change option to generate Gerber and Drill files
2023-10-18 Increase some hole from JLCPCB 3d preview and fix USB-C position
2023-10-26 Remove dependency on shared lib
2024-12-27 Fix inverted battsense Op Amp, remove adc in clamp diode, invert din and dout silkscreen
2025-01-06 Update for kikad 8 and use new script to generate pos
2025-04-24 Some BOM and gerber export fix and improvement
